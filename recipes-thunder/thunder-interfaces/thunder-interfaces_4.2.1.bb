require ./thunder-interfaces.inc

SRCREV = "7680dc5c0b248e26ba61972e59c63dc064c2be05"
