require ./thunder-tools.inc

SRCREV = "53bdc7e2bb12497a228ff5694190c51e5dd533af"
