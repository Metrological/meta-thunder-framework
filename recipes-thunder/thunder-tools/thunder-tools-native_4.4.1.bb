require ./thunder-tools.inc

SRC_URI = "git://github.com/rdkcentral/ThunderTools.git;protocol=git;branch=${RECIPE_BRANCH};protocol=https"

SRCREV = "790c7f0e80fbbe877c86c52c0f1784fffca16dfc"
