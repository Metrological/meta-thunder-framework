require ./thunder-clientlibraries.inc

SRCREV = "a98c4a0b28edd62f4e14cfb29c217a024b99f19c"
