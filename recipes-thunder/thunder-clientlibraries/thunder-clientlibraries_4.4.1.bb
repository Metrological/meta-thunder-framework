require ./thunder-clientlibraries.inc