require ./thunder-clientlibraries.inc

SRCREV = "1413f9dfc5f53001ac1a4ac71751d4b03406e36a"
