require ./thunder-clientlibraries.inc

SRCREV = "09689520670fcb3d34ba4703e6f823b87e64fa43"
