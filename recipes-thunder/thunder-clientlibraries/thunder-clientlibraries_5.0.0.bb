require ./thunder-clientlibraries.inc

SRCREV = "aded8f779779289145085db5b1cc4c3da2a6cb9b"
