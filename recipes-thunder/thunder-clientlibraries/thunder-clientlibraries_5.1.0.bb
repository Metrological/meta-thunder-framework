require ./thunder-clientlibraries.inc

SRCREV = "910022d1aada134cdf63b9c5bf8021f1a9c928ed"
