require ./thunder-clientlibraries.inc

SRCREV = "09a75a85e1263e0520f182dea6dc19c673e070a1"

SRC_URI += "\ 
file://0001-Fix-Weston-Compositor.patch \
"
