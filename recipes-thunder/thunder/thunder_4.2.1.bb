require ./thunder.inc

SRC_URI += "file://ThunderTools-path-variable-added-for-Tools-cmake-path.patch"

SRCREV = "0d6aa9664f780053818d1bbd211cdcf69ec2e9aa"
