require ./thunder.inc